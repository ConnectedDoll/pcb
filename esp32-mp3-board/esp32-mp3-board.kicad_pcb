# Repository ConnectedDoll/pcb

File README.md:

# ConnectedDoll PCB
ESP32 に MAX98357A搭載 I2S 3W D級アンプ その他を搭載したボード  
MP3再生は ファームウェア (ソフトウェアコーディック) を想定

# 基板CAD
[KiCAD 5.1.5](https://kicad-pcb.org/blog/2019/11/KiCad-5.1.5-Release/)

# 部品概要
部品詳細 は [bom](./bom/) 参照。  

|部品名|概要|
|:--|:--|
| ESP32-WROOM-32 | WiFi モジュール |
| MAX98357AETE+T | I2S 3W D級アンプ |
| WS2812S | シリアルLED |

# 回路図
回路図 詳細は [PDF](./esp32-mp3-board/esp32-mp3-board.pdf) 参照  

# 参考
[Adafruit HUZZAH32 - ESP32 Feather](https://learn.adafruit.com/assets/41630)  
[Adafruit MAX98357 I2S Class-D Mono Amp](https://learn.adafruit.com/assets/32642)  
[FTDI USBシリアル変換アダプター Rev.2](https://www.switch-science.com/catalog/2782/)  
[CHEATING AT 5V WS2812 CONTROL TO USE 3.3V DATA](https://hackaday.com/2017/01/20/cheating-at-5v-ws2812-control-to-use-a-3-3v-data-line/)

## KiCad design esp32-mp3-board/esp32-mp3-board.kicad_pcb

Parts:
C1, C2, C3, C5, C7: 10uF; C0603
C4: 0.1uF; C0603
C6, C8: 1uF; C0603
C9, C10: 220pF; C0603
D1: D_Schottky; D_SOD-123
D2: LED; LED_0603_1608Metric
D3, D4: WS2812S; LED_WS2812_PLCC6_5.0x5.0mm_P1.6mm
D5: 1N4148; SOD-123; MPN 1N4148
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J2: Conn_01x02; H2-2.54
J3: UART; H6-2.54
J4: TOUCH; H3-2.54
J5: Conn_01x04; H4-2.54
L1, L2: SMD-FERRITE; R0603; MPN BLM18AG121SN1D
Q1, Q2: S9013; TSOT-23; MPN S9013
R1, R2: 100k; R0603
R3: 1M; R0603
R4, R5, R6: 10k; R0603
R7: 100; R0603
R9: 1k; R0603
R10, R11: 5.1K; R0603
SW1: SW_PUSH; SW_Push_1P1T_NO_CK_KMR2; Part Number KMR211NG LFS
U1: AP2112K-3.3; SOT-23-5
U2: ESP32-WROOM-32
U3: MAX98357AETE+T; MAX98357A; Part Number MAX98357AETE+T
X1, X2: Conn_01x02; H2-2.54

Connections:
+3V3: C3.1, C4.1, C5.1, C6.1, C7.1, D3.3 (VCC), D4.3 (VCC), J3.4, J5.2, R3.1, R4.1, U1.5 (VOUT), U2.2 (VDD), U3.7 (VDD)
/BCLK: U2.11 (IO26), U3.16 (BCLK)
/DIN: U2.33 (IO21), U3.1 (DIN)
/DTR: J3.1, Q1.2 (E), R6.2
/GAN: U3.2 (GAIN_SLOT)
/IO0: Q1.3 (C), U2.25 (IO0)
/IO4: R7.2, U2.26 (IO4)
/IO13: R9.1, U2.16 (IO13)
/LRCLK: U2.10 (IO25), U3.14 (LRCLK)
/RX: J3.3, U2.34 (RXD0/IO3)
/SCL: J5.4, U2.36 (IO22)
/SDA: J5.3, U2.37 (IO23)
/T7: J4.3, U2.12 (IO27)
/T8: J4.2, U2.8 (IO32)
/T9: J4.1, U2.9 (IO33)
/TX: J3.2, U2.35 (TXD0/IO1)
/VD+: C10.1, L1.2, X1.1, X2.1
/VD-: C9.1, L2.2, X1.2, X2.2
/VDD: D3.5 (VDD), D4.5 (VDD), D5.2 (-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D2.1 (K), D3.6 (VSS), D4.6 (VSS), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J3.6, J5.1, R1.2, R10.1, R11.1, SW1.1, U1.2 (GND), U2.1 (GND), U2.15 (GND), U2.38 (GND), U2.39 (GND), U3.3 (GND)
unnamed: C2.1, D1.1 (K), R2.1, U1.1 (VIN)
unnamed: D2.2 (A), R9.2
unnamed: D3.1 (DOUT), D4.2 (DIN)
unnamed: D3.2 (DIN), R7.1
unnamed: J1.A5 (CC1), R10.2
unnamed: J1.B5 (CC2), R11.2
unnamed: L1.1, U3.9 (OUTP)
unnamed: L2.1, U3.10 (OUTN)
unnamed: Q1.1 (B), R5.1
unnamed: Q2.1 (B), R6.1
unnamed: R2.2, U1.3 (EN)
unnamed: R3.2, U3.4 (~SD_MODE)
VBUS: C1.1, D1.2 (A), D5.1 (+), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R1.1

Notes on the sheet:
https://learn.adafruit.com/assets/32642 https://learn.adafruit.com/assets/41630 https://www.switch-science.com/catalog/2782/ https://hackaday.com/2017/01/20/cheating-at-5v-ws2812-control-to-use-a-3-3v-data-line/
POWER
RESET
AUTORESET
LED
UART
USB Type-C
TOUCH
AUDIO
MAX98357AETE+T
ESP32
RGB LED
I2C

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
Board: 2 copper layers, 60.0 x 60.0 mm, 40 parts (0 on the bottom side), 34 nets.

## Commit log

2020-06-03 add ALL
2020-06-03 回路図pdf 追加
2020-06-05 WS2812S まわり修正
2020-07-13 add .gitignore
2020-07-13 add dom
2020-07-13 Revert "add dom"
    This reverts commit a930d9fe9ae82e409cacf9305f4a82298515c342.
2020-07-13 add bom
2020-07-13 add esp32-mp3-board
2020-07-13 add README.md
2020-10-02 RESET回路 EN端子指定の誤りを修正
2020-10-09 RTS追加 CTS回路修正
